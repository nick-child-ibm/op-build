## openpower/package/secvarctl/Config.in
```kconfig
config BR2_PACKAGE_SECVARCTL
    bool "secvarctl"
    depends on BR2_PACKAGE_SKIBOOT
    help
      Tool for managing Secure Boot keys
```
